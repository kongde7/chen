# Keil uVision project MEC.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MEC
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _LCD_LANDSCAPE
  c include: ..\BSP\include;..\CMSIS\inc;..\Drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../CMSIS/src/: startup_LPC17xx.s
  group BSP
    ../BSP/source/: BSP_Config.c joystick.c key.c LCD.c led.c
  group APP
    ./source/: Always.c Date.c Home.c IIC.c main.c More.c Other.c Time.c
    ../Drivers/source/: 24LC02.c
  group CMSIS
    ../CMSIS/src/: core_cm3.c system_LPC17xx.c
  group Drivers
    ../Drivers/source/: lpc1768_uart_polling.c monitor.c command.c lpc1768_rtc.c lpc1768_timer.c lpc1768_i2c.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
